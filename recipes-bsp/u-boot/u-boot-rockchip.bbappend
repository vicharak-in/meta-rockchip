UBOOT_EXTLINUX_FDT:rk3399-vaaman = "/rk3399-vaaman-linux-rk3399-vaaman.dtb"
UBOOT_EXTLINUX_FDT:rk3588-axon   = "/rk3588-axon-linux-rk3588-axon.dtb"
